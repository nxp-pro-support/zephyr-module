## lib/cow/Kconfig
```kconfig
config COW
	bool "Support for cow command"
	help
	  This option enables the 'cow' command
```
